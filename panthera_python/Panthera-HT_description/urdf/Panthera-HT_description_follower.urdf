Commit message: Initialize the Wayland repository

File: panthera_python/Panthera-HT_description/urdf/Panthera-HT_description_follower.urdf (robot description, URDF)
Before this commit: robot Panthera-HT_description, 8 links, 7 joints
Links:
- link link6: mass 0.30 -> 0.45
