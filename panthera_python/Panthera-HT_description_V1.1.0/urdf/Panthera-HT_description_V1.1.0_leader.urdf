Commit message: update readme&yaml

File: panthera_python/Panthera-HT_description_V1.1.0/urdf/Panthera-HT_description_V1.1.0_leader.urdf (robot description, URDF)
Before this commit: robot Panthera-HT_description_V1.1.0, 10 links, 9 joints
Links:
- link gripper_center_link: mass 0.22 -> 0.3
